# Keil uVision project 实验例程.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 实验例程
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\Libraries\inc;..\USER;..\Project;..\Libraries\src;..\Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTCODE
    ../CMSIS/: startup_stm32f10x_md.s
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group USER
    ../USER/: main.c gpio.c servo.c
